do_compile_prepend () {
	export GOCACHE="${B}/.cache"
}
